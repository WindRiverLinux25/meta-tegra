SRC_URI:append = "file://0001-lttng-tracepoint-discard-warning-message-on-NVDA-pla.patch \
                 "
